# Repository thorpej/CoPicoVision

File README.md (part):

# CoPicoVision - A ColecoVision clone using a Raspberry Pi Pico with pico9918 for video
The CoPicoVision stems from yet another bout of nostalgia for a time before
photorealistic video games, when all we had was blocky tile graphics and a
few bleeps and bloops and gosh darn it, we liked it!  When I was a kid, I got
a ColecoVision one Christmas and I played the h*ll out of it.  Alas, I no
longer have it, but I wish I still did, and building a clone seems a lot more
fun than over-paying for one on eBay.

Ok, fine, I have a second motive: It also serves as a test mule for using
modified variants of Troy Schrapel's excellent
[pico9918](https://github.com/visrealm/pico9918) project, something I'm
considering using in other projects, and test mules that can play Mr. Do!
and Zaxxon (yes, yes, yes, and Donkey Kong) are the best kinds of test mules.

This work is licensed under the [Creative Commons Attribution
ShareAlike 4.0 International license](https://creativecommons.org/licenses/by-sa/4.0/).

## Project Status
### Update - Feb 21, 2025
I've had some time recently to test my one built-up rev 2.0 board (with
all of the necessary rework performed).  I found that one rework procedure
was incomplete, and therefore I'm recommending that others do not build up
any 2.x boards at this time.  I managed to spot the problem and avoided
damaging any chips, but I'd rather be safe than sorry.  I also discovered
another bug, of sorts, in the memory decoding logic when testing an SGM
game ("1942").  Spoiler alert: SGM games are not working correctly yet.
The issue revolves around the way address lines A10-A12 are gated to
provide the stock ColecoVision RAM "mirroring" behavior.  Those lines are
gated too aggressively, and a change to the MEMDEC GAL and a change to
the input signal to the 74HCT08 that gates those lines was required.  I
discovered this using a memory map test utility I wrote for this purpose.
I still don't understand how this bug would break "1942", though, so I
still have some work to do.

### Update - Jan 23, 2025
I received the rev 2.0 boards a little while ago, and the other night started
building one up, only to realize I forgot to oder some parts.  Oh well,
no big deal... I have some travel planned for the next few days, and when
I get back, the parts will be here.  I'm continuing to make tweaks to the
rev 3.0 board, replacing through-hole components with surface-mount
equivalents; it's really amazing how much faster it is to build up a
board with surface-mount bits.  The rev 2.0 CoPicoVision is by far my
most ambitious SMT project to date, and rev 3.0 will be even MOAR.

I've settled on rev 3.0 being the final "classic" CoPicoVision (barring
bugs, obviously), but I am already thinking about a rev 4.0 that will
eliminate the out-of-production audio chips in favor of a second Pi Pico
that will emulate both the SN76489AN and the AY-3-8910.  I'm going to
spend a lot of time breadboarding that before I make the leap, but it's
my goal to eliminate those hard to source parts.  Only the Z80A will remain,
and it's still somewhat available (for now, at least).

### Update - Jan 7, 2025
I've done some work to update to the latest version of pico9918, and
submitted a PR for my build parameterization changes.

### Update - Dec 31, 2024
Ok, I am tagging rev 2.1 that contains the MEMDEC fix and has a rework
procedure involving an interposer board for the AY-3-8910 clock issue.
I don't plan to actually spin any of these boards myself, but it's a
checkpoint (and I am spinning a run of interposers).

Happy New Year, everyone!

### Update - Dec 30, 2024
Aaaaand I've realized I made another error, this time in the SGM extended
memory support.  Specifically, when disabling the BIOS ROM.  I foolishly
used /WR as an input signal to the decoder, completely forgetting the
fact that the Z80 memory cycle timings are very different from the I/O
cycle timings.  To fix this, I'm going to need to change the MEMDEC GAL
inputs and equations (it should take /RD as an input rather than /WR).
I will post a re-work for the rev 2.0 boards (it will involve cutting a
trace and running a short bodge wire between the Z80 and the MEMDEC GAL).

### Update - Dec 29, 2024
I've realized that I made a major error in the clock frequency for the
AY-3-8910, and this is going to require me to spin the board.  Basically,
I used the CPUCLK as the input to the AY-3-8910, when it actually needs
to be divided by 2.  I can do that by adding a D-FF.  I'll make an
interposer board for rev 2.0 systems that sits between the AY-3-8910
and the main board that carries the FF chip.  If that works out OK,
I'll just probably put that down on the main board in rev 3.0, rather
than overhauling the whole clock circuit.

### Update - Dec 21, 2024
Ok, I think I'm going to tag a 2.0 pre-release and get the boards off to
fabrication.  I don't really anticipate making any more board changes in
the short term -- just hanges to ancillary documents.  So stay tuned for
that!

### Update - Dec 19, 2024
Well, I had some time to kill on a plane, so I started the process to
claw back board real estate in order to fit the additional components
needed for "Super CoPicoVision".  But of course, once the initial shrink
was done, I needed to know where the additional components would fit before
I re-routed the board.  This of course meant that I needed to actually
add these additional components to the board, meaning that I needed to do
the work to add them to the schematic.  Anyway, you can probably guess
where this is going!  I need to now fix up the BOM (when you're ordering
ICs in surface-mount packages, you need to be a little more specific about
which part number you order!)

### Update - Dec 15, 2024
I had to take a break from CoPicoVision for a little while for various
reasons, but I'm trying to get back to it.  After mulling it over and
thinking about future "Super CoPicoVision" plans, I decided to change the
audio output buffer to a TL071 opamp, taking advantage of the -5V rail I
have at my disposal.  I added an LTspice simulation of the circuit, including
passively mixing in the output of an AY-3-8910, which would be present on
this hypothetical "Super CoPicoVision".  I want to get this send off to the
fab soon and if everthing is fine, call this version "CoPicoVision 1.0".

I do plan to keep working on it, though!  I plan on experimenting with
the layout, switching to SMT components as necessary, to see if I can fit
the extra chips needed for the Super flavor within the same board footprint.

### Update - Nov 10, 2024
I finally got a chance to get set up with some powered speakers (with a
volume control) to get a better sense of how the audio section behaves.
With the AudioEngine 2+ speakers I tested with, the noise isn't really
that bad at all, and it definitely seems to be a property of the SN76489AN
(placing my finger on top of the chip while running makes an audible
different in the noise profile).

I haven't yet bodged the audio section changes in revision 0.2 onto this
revision 0.1 board.  I really should try to do that soon and re-evaluate.

### Update - Oct 12, 2024
I've updated the schematic and PCB to fix the swapped controller bug in
the rev 0.1 boards, and bumped the revision to 0.2.

I've also built up the audio section of the board and confirmed that it
works.  It's not ideal, though:
* The footprint for the resistor in the emitter-follower is wrong, so even
the relatively-small 1/2 watt resistor I spec'd doesn't quite fit.
* I should have put a current-limiting resistor between the SN76489AN and
the emitter-follower.  It works as it is, but the current setup has the
SN76489AN sourcing more current than it really ought to.  (Maybe I should
have just used a 2N7000 in a source-follower configuration instead?)
* The output is pretty noisy.  It's not _distorted_, but there's hiss and
other audio artifacts.  I remember the original ColecoVision being this
way, but always assumed it was the fault of the RF modulator.  I may bodge
in a passive low-pass filter to cut down on the noise.

### Update - Oct 11, 2024
Built up the controller section and played some Donkey Kong!  I did make
a mistake on the controller section, however.  Controller 1 and 2 are
swapped.  I will correct this in the next revision of the board, and there
is a [procedure](errata/rev0_1_controller_bodge.md) to fix the rev 0.1 boards
that I've already run off.

There also a mistake in the physical placement of the card edge connector
for the cartridge.  It's a few millimeters too close to the front of the
board, and so the cartridge bumps into one of the 2N3904s in the controller
circuit and the cartridge doesn't quite align with the silk screen outline.
That's going to be a little tricker to fix because I might have to re-route
some of the board, but I'll fix that up as well.

Guess I should build the audio section next!

### Update - Oct 10, 2024
After replacing a bad oscillator, the first test board is working!  I have
not yet installed the audio or controller circuitry yet, but I can boot up
Donkey Kong and Buck Rogers, and, due to the lack of controller circuitry
being misinterpreted as input, game play starts!

### Update - Sept 24, 2024
Boards have been back for a while now, and I finally got around to starting
to build one up.  Thought I had all of the resistors I needed in my inventory,
but alas, I did not, so need to place a Jameco order!

### Update - Sept 2, 2024
I made some small adjustments to the PCB, and sent rev 0.1 off for
fabrication!

### Update - Sept 1, 2024
I made forks of pico9918 and vrEmuTms9918 in order to make the changes
needed for CoPicoVision, and then went ahead and made all of those
changes.  Initial firmware version checked in!

### Initial - Aug 31, 2024
The initial "rev 0.1" hardware design is done and ready to send off for
fabrication.  There is some software work to do on the pico9918 side of
things, but the changes I have in mind are trivial.  My plan is to wrap
my changes in proper configuration options and feed those changes back
to Troy.

So, yah, it's early!  Watch this space!

## Design philosophy
My initial goal was to play ColecoVision games (and subsequently, also
games that require the Super Game Module), not to produce a faithful
clone of the circuit.  It needs to be fully-compatible with ColecoVision
and SGM games, but that's the extent of it.  As such, some shortcuts are
going to be taken.

First of all, I'm using Troy Schrapel's excellent pico9918 engine for the video
display.  This reduces the number of vintage parts that need to be sourced, and
gives me VGA video output.  I won't be using the pico9918 as-is, however; since
I don't need all of the outputs of a real TMS9918A (no CPUCLK or GROMCLK), I'm
using a modified pico9918 firmware that doesn't bother with those outputs and
thus allows me to use a regular Raspberry Pi Pico as a module.

Second of all, I'm not going to bother with the expansion interface; I don't
particularly care about connecting an Adam module, and if I ever do, then it
will be time to re-evaluate my life choices.

And lastly, as should be obvious through my use of a microcontroller that's
hundreds of times more powerful than the ColecoVision itself, I have no qualms
about using programmable logic to reduce the part count and generally simplify
the design.  In particular, this means GAL22V10s for address decoding and other
glue logic rather than general-purpuse 7400-series parts.  Atmel still makes
a compatible part, and there are open source tools for programming them, so the
design is still very accessible.

There are three "vintage" parts that are required for the CoPicoVision:
* A 4MHz-capable Z80 CPU in a DIP-40 package.
* A TI SN76489AN sound chip.
* A General Instrument AY-3-8910 sound chip (a Yamaha YM2149 will probably
  also work, but I don't have any to try).  This is only needed if you want
  to be able to play SGM games; regular ColecoVision games will work without
  it.

Eventually, I'd like to replace the SN76489AN and AY-3-8910s with emulated
parts, (almost certainly using a Pi Pico), but for now the real thing needs
to be sourced.

Obviously, with the Z80 now being EOL'd, that poses a bit of a snag.  Luckily,
I have a stash of modern CMOS Z80s, and this design will also accept a vintage
NMOS Z80.  The CPU is clocked at 3.57MHz, so a Z80A or better is necessary.
Maybe one day I'll evaluate one of the FPGA Z80 cores floating around
to see if it's feasible to use one of those with an iCE40 FPGA in an updated
version of the CoPicoVision.  But for now, a genuine Z80 must be used.

## Design details
I spent some time mulling over how I wanted to approach this board.  I
considered doing an all-SMT board (except for the stuff that was only
available as through-hole), but for the first version of the board I
ultimately went with mostly through-hole parts (except for the power supply)
in order to try and keep a more retro look.

This wasn't feasible for version 2, the "Super CoPicoVision"; I wanted to
keep the same basic envelope, so I had no choice to shrink the components
in order to make space for the additional logic chips and the large DIP-40
AY-3-8910.  So, I converted all of the individual resistors and ceramic
capacitors to 0805 packages, and the RAM and most logic ICs to SOIC packages
(I left the 74LS541s in the controller input section as DIP packages).

The board is 4 layers: signals (and ground fill) top and bottom, along with
an internal ground plane and power plane.  I arrived at the size of the board
through experimentation; essentially, I did a rough layout of the board into
what I thought "looked pretty good", placed mounting holes and keep-outs, and
then drew an edge-cut box around it.  Once the box was drawn, I tried to stay
within that envelope.  I'm a total novice when I comes to PCB layout and
design, and I routed the entire board by hand, but did manage to make it fit.
Some signals are routed, ahem, interestingly, but this isn't a high-speed
design so it should be just fine.

The font of the board has power and reset buttons and the 2 controller
ports.  The rear of the board has power, audio, and VGA jacks, along with
the USB connector for the Raspberry Pi Pico in case there's a need to
update the pico9918 firmware.  There's a diode in between the Pico and
the rest of the board, so it's safe to update the firmware in situ.

I've included a bill of materials with Mouser part numbers for just about
everything, including the jellybean SMT resistors / capacitors in standard
0805 packages; these jellybean parts can be substituted with equivalent stock
you might have on hand, of course, but I included Mouser part numbers for
convenience.  For the DIP chip sockets, you whatever kind you prefer.  For
the push button switches, there are lots of garden-variety 6mm through-hole
momentary push buttons out there, so you whatever you prefer.

### Power supply
The power supply is fairly simple, since we don't need the -12V rail that's
found on the original ColecoVision.  We do, however, require a -5V rail, which
is used as a bias voltage in the controller interface circuit as well as for
the op-amp used as an output buffer in the audio circuit.

Power comes in via a USB-C connector (with ESD protection diodes on the
control channel signals).  Power is switched using a MAX16054 on/off
supervisor chip that controls a high-side P-FET to supply power to the
rest of the system.  The MAX16054 is controlled using a single momentary
pushbutton.

The -5V rail is generated using an ICL7660A charge pump chip.

### Clock and reset generation
On the first revision of the CoPicoVision, the clock circuit was as simple
as it gets: a simply a 3.579545 MHz DIP-8 oscillator can that drove the
whole thing, providing CPUCLK signal to the Z80, the M1 wait-state generator,
and the SN76489AN sound chip.

When the Super Game Module enhancements were added in rev 2.0, this clock
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
## KiCad design errata/rev2_x_ay_interposer/rev2_x_ay_interposer.kicad_pcb

Parts:
C101: 0.1µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
U101: AY-3-8910; DIP-40_W15.24mm
U102: AY-3-8910; DIP-40_W15.24mm_Socket
U103: MM74HCT74M; SOIC-14_3.9x8.7mm_P1.27mm; Mouser 512-MM74HCT74MX

Connections:
/A8: U101.25 (A8), U102.25 (A8)
/A9: U101.24 (~A9), U102.24 (~A9)
/BC1: U101.29 (BC1), U102.29 (BC1)
/BC2: U101.28 (BC2), U102.28 (BC2)
/BDIR: U101.27 (BDIR), U102.27 (BDIR)
/CPUCLK: U101.22 (CLOCK), U103.3 (C)
/DA0: U101.37 (DA0), U102.37 (DA0)
/DA1: U101.36 (DA1), U102.36 (DA1)
/DA2: U101.35 (DA2), U102.35 (DA2)
/DA3: U101.34 (DA3), U102.34 (DA3)
/DA4: U101.33 (DA4), U102.33 (DA4)
/DA5: U101.32 (DA5), U102.32 (DA5)
/DA6: U101.31 (DA6), U102.31 (DA6)
/DA7: U101.30 (DA7), U102.30 (DA7)
/IOA0: U101.21 (IOA0), U102.21 (IOA0)
/IOA1: U101.20 (IOA1), U102.20 (IOA1)
/IOA2: U101.19 (IOA2), U102.19 (IOA2)
/IOA3: U101.18 (IOA3), U102.18 (IOA3)
/IOA4: U101.17 (IOA4), U102.17 (IOA4)
/IOA5: U101.16 (IOA5), U102.16 (IOA5)
/IOA6: U101.15 (IOA6), U102.15 (IOA6)
/IOA7: U101.14 (IOA7), U102.14 (IOA7)
/IOB0: U101.13 (IOB0), U102.13 (IOB0)
/IOB1: U101.12 (IOB1), U102.12 (IOB1)
/IOB2: U101.11 (IOB2), U102.11 (IOB2)
/IOB3: U101.10 (IOB3), U102.10 (IOB3)
/IOB4: U101.9 (IOB4), U102.9 (IOB4)
/IOB5: U101.8 (IOB5), U102.8 (IOB5)
/IOB6: U101.7 (IOB6), U102.7 (IOB6)
/IOB7: U101.6 (IOB7), U102.6 (IOB7)
/OUT_A: U101.4 (OUT_A), U102.4 (OUT_A)
/OUT_B: U101.3 (OUT_B), U102.3 (OUT_B)
/OUT_C: U101.38 (OUT_C), U102.38 (OUT_C)
/RESET: U101.23 (~RESET), U102.23 (~RESET), U103.1 (~R)
/TEST1: U101.39 (TEST1), U102.39 (TEST1)
/TEST2: U101.26 (TEST2/~SEL), U102.26 (TEST2/~SEL)
GND: C101.2, U101.1 (GND), U102.1 (GND), U103.7 (GND), U103.11 (C), U103.12 (D)
unnamed: U102.22 (CLOCK), U103.5 (Q)
unnamed: U103.2 (D), U103.6 (~Q)
VCC: C101.1, U101.40 (VCC), U102.40 (VCC), U103.4 (~S), U103.10 (~S), U103.13 (~R), U103.14 (VCC)

Notes on the sheet:
Socket to accept AY-3-8910 on interposer.
Pins that interface to main CoPicoVision board.

Board: 2 copper layers, 30.2 x 54.9 mm, 4 parts (0 on the bottom side), 40 nets.

## KiCad design design-files/CoPicoVision.kicad_pcb

Board: 4 copper layers, 165.8 x 110.0 mm, 117 parts (0 on the bottom side), 156 nets.

Parts:
C101, C103, C104, C108, C201, C202, C203, C204, C205, C206, C301, C302, C401, C402, C403, C406, C409, C501, C505, C506: 0.1µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C102, C105: 100µF; CP_Radial_D6.3mm_P2.50mm
C106, C107: 10µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C404, C405, C412, C413: 0.01µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C407, C411: 100pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C408, C410: .047µF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C502: 22µF; CP_Radial_D6.3mm_P2.50mm
C503, C504: 2.2µF; CP_Radial_D6.3mm_P2.50mm
D101: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D102: ESDA25L; SOT-23
D103: Power LED; LED_D3.0mm
D301: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
D401, D402: 1N4001; D_DO-41_SOD81_P10.16mm_Horizontal
H101, H102, H103, H104, H105, H106, H107, H108: MountingHole; MountingHole_3.5mm
J101: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4085
J102: Conn_02x15_Odd_Even; Sullins_Cart_Slot
J301: DE15_Receptacle_HighDensity_MountingHoles; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset8.35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
J401: Controller 1; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
J402: Controller 2; DSUB-9_Male_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_Hou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
J501: AudioJack3; Jack_3.5mm_CUI_SJ1-3523N_Horizontal
Q101: MMFTP3334K-AQ; SOT-23
Q401, Q402: 2N3904; TO-92_Inline
R101, R102: 5K1; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R103, R409, R412, R502: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R104: 3K3; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R105: 330R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R401, R402: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R403, R404, R413: 1.5K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R405, R406: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R407, R410: 1.8K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R408, R411: 22K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R414, R415: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R501, R503, R504, R505: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
RN101: 3K3; R_Array_SIP5
RN301, RN302, RN303, RN304, RN305, RN306, RN307: 1K; R_Array_SIP8
RN401, RN402: 22K; R_Array_SIP8
SW101, SW102: SW_Push; SW_PUSH_6mm
U101: Z80CPU; DIP-40_W15.24mm_Socket
U102: DS1813; TO-92_Inline
U103: MC74ACT05DR2G; SOIC-14_3.9x8.7mm_P1.27mm
U104: ICL7660A; SOIC-8_3.9x4.9mm_P1.27mm
U105: MAX16054; SOT-23-6
U201, U202: GAL22V10; DIP-24_W7.62mm_Socket
U203: AT28C64; DIP-28_W15.24mm_Socket
U204: AS6C62256; SOIC-28W_7.5x17.9mm_P1.27mm
U205: MM74HCT08MX; SOIC-14_3.9x8.7mm_P1.27mm
U206: MM74HCT74MX; SOIC-14_3.9x8.7mm_P1.27mm
U301: Pico; RPi_Pico_SMD_TH
U302, U303: SN74LVC245ADWR; SOIC-20W_7.5x12.8mm_P1.27mm
U401, U402: 74LS541; DIP-20_W7.62mm_Socket
U403: SN74HCT00DR; SOIC-14_3.9x8.7mm_P1.27mm
U501: SN76489AN; DIP-16_W7.62mm_Socket
U502: TL071; DIP-8_W7.62mm_Socket
U503: AY-3-8910; DIP-40_W15.24mm_Socket
U504: SN74HCT02D; SOIC-14_3.9x8.7mm_P1.27mm
X101: 3.579545MHZ; Oscillator_DIP-8

Connections:
+3V3: C301.1, C302.1, U301.36 (3V3), U302.20 (VCC), U303.20 (VCC)
-5V: C107.1, R403.2, R404.2, U104.5 (VOUT), U502.4 (V-)
/Controller Interface/2V5: R401.2, R402.1, RN401.1 (common), RN402.1 (common)
/Controller Interface/C1_1: J401.1, RN401.2 (R1), U401.2 (A0)
/Controller Interface/C1_2: J401.2, RN401.4 (R3), U401.4 (A2)
/Controller Interface/C1_3: J401.3, RN401.5 (R4), U401.5 (A3)
/Controller Interface/C1_4: J401.4, RN401.3 (R2), U401.3 (A1)
/Controller Interface/C1_6: J401.6, RN401.8 (R7), U401.8 (A6)
/Controller Interface/C1_7: J401.7, RN401.7 (R6), U401.7 (A5)
/Controller Interface/C1_9: J401.9, R407.1
/Controller Interface/C1_D4: C408.1, RN401.6 (R5), U401.6 (A4), U403.12
/Controller Interface/C1_D7: C407.1, C412.1, R408.1, U401.9 (A7), U403.11
/Controller Interface/C2_1: J402.1, RN402.2 (R1), U402.2 (A0)
/Controller Interface/C2_2: J402.2, RN402.4 (R3), U402.4 (A2)
/Controller Interface/C2_3: J402.3, RN402.5 (R4), U402.5 (A3)
/Controller Interface/C2_4: J402.4, RN402.3 (R2), U402.3 (A1)
/Controller Interface/C2_6: J402.6, RN402.8 (R7), U402.8 (A6)
/Controller Interface/C2_7: J402.7, RN402.7 (R6), U402.7 (A5)
/Controller Interface/C2_9: J402.9, R410.1
/Controller Interface/C2_D4: C410.1, RN402.6 (R5), U402.6 (A4), U403.9
/Controller Interface/C2_D7: C411.1, C413.2, R411.1, U402.9 (A7), U403.8
/Controller Interface/~NESW_EN: C405.2, J401.8, J402.8, R406.1
/Controller Interface/~PAD_EN: C404.1, J401.5, J402.5, R405.1
/VBUS: J101.A9 (VBUS), J101.B9 (VBUS), Q101.2 (S), R103.1, U105.6 (Vcc)
/Video/B0: RN304.1 (R1.1), U301.14 (GPIO10)
/Video/B1: RN307.1 (R1.1), U301.15 (GPIO11)
/Video/B2: RN301.5 (R3.1), U301.16 (GPIO12)
/Video/B3: RN307.5 (R3.1), RN307.7 (R4.1), U301.17 (GPIO13)
/Video/CD0_L: U301.27 (GPIO21), U303.2 (A0)
/Video/CD1_L: U301.26 (GPIO20), U303.3 (A1)
/Video/CD2_L: U301.25 (GPIO19), U303.4 (A2)
/Video/CD3_L: U301.24 (GPIO18), U303.5 (A3)
/Video/CD4_L: U301.22 (GPIO17), U303.6 (A4)
/Video/CD5_L: U301.21 (GPIO16), U303.7 (A5)
/Video/CD6_L: U301.20 (GPIO15), U303.8 (A6)
/Video/CD7_L: U301.19 (GPIO14), U303.9 (A7)
/Video/G0: RN303.1 (R1.1), U301.9 (GPIO6)
/Video/G1: RN306.1 (R1.1), U301.10 (GPIO7)
/Video/G2: RN301.3 (R2.1), U301.11 (GPIO8)
/Video/G3: RN306.5 (R3.1), RN306.7 (R4.1), U301.12 (GPIO9)
/Video/HSYNC: J301.13, U301.1 (GPIO0)
/Video/INT_L: U103.3, U301.29 (GPIO22)
/Video/MODE_L: U301.34 (GPIO28_ADC2), U302.2 (A0)
/Video/R0: RN302.1 (R1.1), U301.4 (GPIO2)
/Video/R1: RN305.1 (R1.1), U301.5 (GPIO3)
/Video/R2: RN301.1 (R1.1), U301.6 (GPIO4)
/Video/R3: RN305.5 (R3.1), RN305.7 (R4.1), U301.7 (GPIO5)
/Video/RUN_L: U301.30 (RUN), U302.5 (A3)
/Video/VGA_B: J301.3, RN301.6 (R3.2), RN304.8 (R4.2), RN307.4 (R2.2), RN307.6 (R3.2), RN307.8 (R4.2)
/Video/VGA_G: J301.2, RN301.4 (R2.2), RN303.8 (R4.2), RN306.4 (R2.2), RN306.6 (R3.2), RN306.8 (R4.2)
/Video/VGA_R: J301.1, RN301.2 (R1.2), RN302.8 (R4.2), RN305.4 (R2.2), RN305.6 (R3.2), RN305.8 (R4.2)
/Video/VSYNC: J301.14, U301.2 (GPIO1)
/Video/~CSR_L: U301.31 (GPIO26_ADC0), U302.4 (A2)
/Video/~CSW_L: U301.32 (GPIO27_ADC1), U302.3 (A1)
A0: J102.7, U101.30 (A0), U201.11 (I11), U203.10 (A0), U204.10 (A0), U302.18 (B0), U504.2
A1: J102.9, U101.31 (A1), U103.5, U201.10 (I10), U203.9 (A1), U204.9 (A1), U401.19 (G2)
A2: J102.11, U101.32 (A2), U201.9 (I9), U203.8 (A2), U204.8 (A2)
A3: J102.15, U101.33 (A3), U201.8 (I8), U203.7 (A3), U204.7 (A3)
A4: J102.17, U101.34 (A4), U201.7 (I7), U203.6 (A4), U204.6 (A4)
A5: J102.21, U101.35 (A5), U201.6 (I6), U203.5 (A5), U204.5 (A5)
A6: J102.23, U101.36 (A6), U201.5 (I5), U203.4 (A6), U204.4 (A6)
A7: J102.25, U101.37 (A7), U201.4 (I4), U203.3 (A7), U204.3 (A7)
A8: J102.28, U101.38 (A8), U203.25 (A8), U204.25 (A8)
A9: J102.26, U101.39 (A9), U203.24 (A9), U204.24 (A9)
A10: J102.16, U101.40 (A10), U203.21 (A10), U205.1
A11: J102.14, U101.1 (A11), U203.23 (A11), U205.4
A12: J102.24, U101.2 (A12), U203.2 (A12), U205.12
A13: J102.19, U101.3 (A13), U202.9 (I9), U204.26 (A13)
A14: J102.20, U101.4 (A14), U202.10 (I10), U204.1 (A14)
A15: U101.5 (A15), U202.11 (I11)
CPUCLK: U101.6 (~CLK), U202.1 (I1/CLK), U501.14 (CLK), U503.22 (CLOCK), X101.5 (OUT)
D0: J102.5, U101.14 (D0), U203.11 (IO0), U204.11 (Q0), U206.2 (D), U303.11 (B7), U401.18 (Y0), U402.18 (Y0), U501.10 (D7), U503.37 (DA0)
D1: J102.3, U101.15 (D1), U203.12 (IO1), U204.12 (Q1), U206.12 (D), U303.12 (B6), U401.17 (Y1), U402.17 (Y1), U501.11 (D6), U503.36 (DA1)
D2: J102.1, U101.12 (D2), U203.13 (IO2), U204.13 (Q2), U303.13 (B5), U401.16 (Y2), U402.16 (Y2), U501.12 (D5), U503.35 (DA2)
D3: J102.4, U101.8 (D3), U203.15 (IO3), U204.15 (Q3), U303.14 (B4), U401.15 (Y3), U402.15 (Y3), U501.13 (D4), U503.34 (DA3)
D4: J102.6, U101.7 (D4), U203.16 (IO4), U204.16 (Q4), U303.15 (B3), U401.14 (Y4), U402.14 (Y4), U501.15 (D3), U503.33 (DA4)
D5: J102.8, U101.9 (D5), U203.17 (IO5), U204.17 (Q5), U303.16 (B2), U401.13 (Y5), U402.13 (Y5), U501.1 (D2), U503.32 (DA5)
D6: J102.10, U101.10 (D6), U203.18 (IO6), U204.18 (Q6), U303.17 (B1), U401.12 (Y6), U402.12 (Y6), U501.2 (D1), U503.31 (DA6)
D7: J102.12, U101.13 (D7), U203.19 (IO7), U204.19 (Q7), U303.18 (B0), U401.11 (Y7), U402.11 (Y7), U501.3 (D0), U503.30 (DA7)
GND: C101.2, C102.2, C103.2, C104.2, C105.2, C107.2, C108.2, C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C301.2, C302.2, C401.2, C402.2, C403.2, C404.2, C405.1, C406.2, C409.2, C501.2, C502.2, C505.2, C506.2, D102.3 (A), J101.A12 (GND), J101.B12 (GND), J101.S1 (SHIELD), J102.13, J102.29, J301.0, J301.5, J301.6, J301.7, J301.8, J301.10, J401.0 (PAD), J402.0 (PAD), J501.S, Q401.1 (E), Q402.1 (E), R101.2, R102.2, R105.1, R402.2, R413.1, R502.2, SW101.2, SW102.1, U101.29 (GND), U102.3 (GND), U103.7 (GND), U103.11, U103.13, U104.3 (GND), U105.2 (GND), U105.3 (CLEAR), U201.12 (GND), U202.12 (GND), U203.14 (GND), U204.14 (GND), U205.7 (GND), U205.9, U205.10, U206.7 (GND), U301.3 (GND), U301.8 (GND), U301.13 (GND), U301.18 (GND), U301.23 (GND), U301.28 (GND), U301.33 (AGND), U301.38 (GND), U301.42 (GND), U302.1 (A->B), U302.10 (GND), U302.11 (B7), U302.12 (B6)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
unnamed: C406.1, R407.2, U403.13
unnamed: C409.1, R410.2, U403.10
unnamed: C503.1, R501.1, R503.1, R504.1, R505.1
unnamed: C504.2, J501.R, J501.T
unnamed: C102.1, D101.2 (A), R104.1, U102.2 (Vcc)
unnamed: D103.1 (K), R105.2
unnamed: D301.1 (K), U301.39 (VSYS)
unnamed: C412.2, D401.2 (A), R414.1
unnamed: D401.1 (K), D402.1 (K), R413.2, U103.9
unnamed: C413.1, D402.2 (A), R415.1
unnamed: D102.2 (K), J101.A5 (CC1), R102.1
unnamed: D102.1 (K), J101.B5 (CC2), R101.1
unnamed: Q101.1 (G), R103.2, U105.4 (~OUT)
unnamed: C407.2, Q401.2 (B), R408.2
unnamed: C408.2, Q401.3 (C), R409.1
unnamed: C411.2, Q402.2 (B), R411.2
unnamed: C410.2, Q402.3 (C), R412.1
unnamed: R403.1, R405.2, U403.3, U403.5
unnamed: R404.1, R406.2, U403.1, U403.6
unnamed: RN101.5 (R4.2), U103.6, U402.19 (G2)
unnamed: RN302.2 (R1.2), RN302.3 (R2.1)
unnamed: RN302.4 (R2.2), RN302.5 (R3.1)
unnamed: RN302.6 (R3.2), RN302.7 (R4.1)
unnamed: RN303.2 (R1.2), RN303.3 (R2.1)
unnamed: RN303.4 (R2.2), RN303.5 (R3.1)
unnamed: RN303.6 (R3.2), RN303.7 (R4.1)
unnamed: RN304.2 (R1.2), RN304.3 (R2.1)
unnamed: RN304.4 (R2.2), RN304.5 (R3.1)
unnamed: RN304.6 (R3.2), RN304.7 (R4.1)
unnamed: RN305.2 (R1.2), RN305.3 (R2.1)
unnamed: RN306.2 (R1.2), RN306.3 (R2.1)
unnamed: RN307.2 (R1.2), RN307.3 (R2.1)
unnamed: C106.1, U104.2 (CAP+)
unnamed: C106.2, U104.4 (CAP-)
unnamed: SW102.2, U105.1 (IN)
unnamed: U103.1, U202.21 (IO8)
unnamed: U204.21 (A10), U205.3
unnamed: U204.23 (A11), U205.6
unnamed: U204.2 (A12), U205.11
unnamed: R501.2, U501.7 (AUDIO_OUT)
unnamed: C503.2, R502.1, U502.3 (+)
unnamed: C504.1, U502.2 (-), U502.6
unnamed: U503.29 (BC1), U504.1
unnamed: U503.27 (BDIR), U504.4
unnamed: R503.2, U503.4 (OUT_A)
unnamed: R504.2, U503.3 (OUT_B)
unnamed: R505.2, U503.38 (OUT_C)
ROMEN: U202.8 (I8), U206.9 (Q)
VCC: C101.1, C103.1, C104.1, C105.1, C108.1, C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C401.1, C402.1, C403.1, C501.1, C502.1, C505.1, C506.1, D101.1 (K), D103.2 (A), D301.2 (A), J102.30, Q101.3 (D), R104.2, R401.1, R409.2, R412.2, R414.2, R415.2, RN101.1 (R1), U101.11 (VCC), U101.25 (~BUSRQ), U103.14 (VCC), U104.8 (V+), U201.24 (VCC), U202.24 (VCC), U203.27 (~WE), U203.28 (VCC), U204.28 (VCC), U205.14 (VCC), U206.4 (~S), U206.13 (~R), U206.14 (VCC), U401.20 (VCC), U402.20 (VCC), U403.14 (VCC), U501.16 (Vcc), U502.7 (V+), U503.25 (A8), U503.28 (BC2), U503.40 (VCC), U504.14 (VCC), X101.8 (Vcc)
XRAMEN: U202.7 (I7), U205.2, U205.5, U205.13, U206.5 (Q)
~AYSEL: U201.15 (IO2), U503.24 (~A9), U504.3, U504.5
~C1WSEL: U201.22 (IO9), U403.2
~C2WSEL: U201.23 (IO10), U403.4
~CRSEL: U201.21 (IO8), U401.1 (G1), U402.1 (G1)
~CRT8SEL: J102.18, U202.17 (IO4)
~CRTASEL: J102.22, U202.16 (IO3)
~CRTCSEL: J102.2, U202.15 (IO2)
~CRTESEL: J102.27, U202.14 (IO1)
~FF1WSEL: U201.20 (IO7), U206.3 (C)
~FF2WSEL: U201.19 (IO6), U206.11 (C)
~INT: RN101.3 (R2.2), U101.16 (~INT), U103.8
~IORQ: U101.20 (~IORQ), U201.1 (I1/CLK)
~M1: U101.27 (~M1), U202.3 (I3)
~MREQ: U101.19 (~MREQ), U202.5 (I5)
~NMI: RN101.4 (R3.2), U101.17 (~NMI), U103.4
~RAMSEL: U202.22 (IO9), U204.20 (~CS)
~RD: U101.21 (~RD), U203.22 (~OE), U204.22 (~OE)
~RESET: SW101.1, U101.26 (~RESET), U102.1 (~RST), U206.1 (~R), U206.10 (~S), U302.15 (B3), U503.23 (~RESET)
~RFSH: U101.28 (~RFSH), U202.2 (I2)
~ROMSEL: U202.23 (IO10), U203.20 (~CE)
~SNWSEL: U201.14 (IO1), U501.5 (~WE), U501.6 (~OE)
~VDPEN: U201.16 (IO3), U303.19 (CE)
~VDPRSEL: U201.18 (IO5), U302.16 (B2)
~VDPWSEL: U201.17 (IO4), U302.17 (B1), U303.1 (A->B)
~WAIT: RN101.2 (R1.2), U101.24 (~WAIT), U103.2, U501.4 (READY)
~WR: U101.22 (~WR), U201.2 (I2), U202.6 (I6), U204.27 (~WE), U504.6

## Commit log (part)

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2024-08-26 Initial README.md
    Introduction, design philosophy, acknowledgements.
2024-08-26 Address decoding for the CoPicoVision, implemented in 2 GAL22V10s. The GALs are somewhat under-utilized, but this saves chips, because otherwise, inverters would be required for some of the input sig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
    IODEC also implements the M1 wait-state generation that is performed
    using a 74LS74 on a real ColecoVision.
2024-08-26 Put the M1 wait-state generator in the MEMDEC; it's more logical for it to be there because it's for dealing with slow memory.
2024-08-27 Add a design details section, and fill in the decoding and memory information.
2024-08-27 Add initial KiCad design files for CoPicoVision. First item: memory and address decoding.
2024-08-27 Reset and clock.
2024-08-27 Use a 74ACT05 rather than a 74LS05.
2024-08-28 Added video circuit.
2024-08-28 Get footprints on everything.
2024-08-28 Add video sheet.
2024-08-28 First pass at rough PCB layout.
2024-08-28 Add controller ports just to get them onto the board.
2024-08-29 Audio section.
2024-08-29 Lay out some additional bits.
2024-08-29 Add power supply. PCB checkpoint.
2024-08-29 Another PCB checkpoint.
2024-08-29 Getting closer with PCB layout.
2024-08-29 Add mounting holes around the cartridge area to reinforce it when carts are being inserted.
2024-08-30 Add cartridge connector.
2024-08-30 PCB checkpoint -- some trace routing done.
2024-08-30 Cartridge slot.
2024-08-30 Describe the power supply and audio sections.
2024-08-30 Clean up net classes for power.
2024-08-30 More routing.
2024-08-30 Fix a reference placement.
2024-08-30 Checkpoint on controller circuit.
2024-08-30 Controller circuit checkpoint.
2024-08-30 Controller checkpoint.
2024-08-31 Final controller checkpoint. Managed to sqeeeze it all onto the board.
2024-08-31 Brand it.
2024-08-31 Most of the controller interface routed.
2024-08-31 Shuffle IODEC outputs to make layout easier.
2024-08-31 Routing checkpoint.
2024-08-31 More branding.
2024-08-31 Another routing checkpoint.
2024-08-31 Use a discrete resistor for the PoR delay, rather than one from the 3K3 resistor pack.
2024-08-31 Use a 4-resistor pack, not 8.
2024-08-31 IODEC fully wired up.
2024-08-31 Cart address bus wired up.
2024-08-31 Cart slot all wired up. Yeesh.
2024-08-31 Tweak verification rules -- passes now.
2024-08-31 Top and bottom ground plane.
2024-08-31 Layout checkpoint.
2024-08-31 Resolve DRC errors / warnings.
2024-08-31 More ground fill.
2024-08-31 Rounded corners.
2024-08-31 Controller block description.
2024-08-31 Some general design details.
2024-08-31 Update a comment.
2024-08-31 Add LICENSE file.
2024-08-31 Add a power LED.
2024-08-31 Move the D103 reference.
2024-08-31 Add board render to the README.
2024-08-31 Re-fill zones after adding LED.
2024-08-31 BoM.
2024-09-01 Add title blocks.
2024-09-01 Add PDF copy of the schematic.
2024-09-01 Project status updates.
2024-09-01 README proof-read.
2024-09-01 Note that pico9918 is covered by its own license terms.
2024-09-01 Add my fork of pico9918 as a submodule, and add a pico9918 build config file for CoPicoVision that restricts pico9918 to harwdware features that a genuine RPI Pico can support and changes the interru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
2024-09-01 Add a built version of the CoPicoVision's pico9918 firmware.
2024-09-02 Update project status.
2024-09-02 My brain got ahead of my fingers when typing that comment I guess.
2024-09-02 Double-check physical dimensions for mounting holes and adjust a few to get them all lined up correctly. Tweak cartridge opening outline to be perfectly[*] centered vis a vis the edge connector.
2024-09-02 Thermal reliefs on inner layers.
2024-09-02 Make sure all the GND pins on the VGA connector are ... connected.
2024-09-02 Add Gerbers for the first PCB rev.
2024-09-02 Note rev 0.1 sent off for fabrication.
2024-09-25 Change R401 and R402 to 220R resistors.
2024-09-25 Project update -- boards are here, starting to build one up!
2024-09-26 Note that a Z80A or better is required.
2024-09-27 Fix typo.
2024-10-11 Controller input works (with caveats).
2024-10-12 Add rev 0.1 errata.
2024-10-12 Add a procedure to fix the swapped controller problem on rev 0.1 boards.
2024-10-12 Link in the procedure to fix the swapped controller problem on rev 0.1 boards.
2024-10-12 Also link the rev 0.1 swapped controller fix in the status section.
2024-10-12 Fix the swapped controller problem that rev 0.1 boards have: the G2 input of the 74LS541 is active-low, so A1 low means Controller 1 is selected.
2024-10-12 Bump to rev 0.2.
2024-10-12 PCB fix for rev 0.1 swapped controller bug.
2024-10-12 Update silk screen for rev 0.2.
2024-10-12 Status update: schematic and PCB fixed for swapped controller bug.
2024-10-13 Note the status of the audio section.
2024-10-15 Use a vertical footprint for R501.
2024-10-16 Add a 0.01uF cap to ground to the emitter-follower input to form a ~10KHz low-pass filter to try and tamp down the hissy noise.
2024-10-16 Route the D3 signal away from the SN76489AN audio output pin.
2024-10-16 Refill zones after previous.
2024-10-17 Move the cartridge connection 1mm towards the rear of the board. I still may need to make futher adjustments here.
2024-10-17 Note the changes in rev 0.2.
2024-10-17 The cartridge connector is about 1.5mm too close to the front of the board, not 2mm.
2024-11-10 Update project status for Nov 10, 2024.
2024-11-24 A start on some notes about how a future "CoPicoVision-SGM" might work.
2024-11-24 Flesh out how extended RAM decoding would work.
2024-11-24 Correct a comment.
2024-11-24 Changes for I/O decoding of the RAM banking flip-flops.
2024-11-25 GI PSG info!
2024-11-25 Use /WR rather than /RD for the extra RAM decode.
2024-11-25 New chip inventory.
2024-11-25 We can do the AY-3-8910 BDIR/BC1 logic with 2 NOR gates.
2024-11-25 Formatting fix.
2024-11-26 Some thoughts about summing the audio outputs.
2024-11-27 Add an LTspice simulation of a possbile SGM audio mixer configuration.
2024-11-27 Note that I've added a simulation for a passive 4-channel chiptune mixer.
2024-11-30 Compat a graphic.
2024-12-15 Project update, and use a TL071 opamp for the audio output buffer.
2024-12-15 All the bypass caps are now 0805s.
2024-12-15 U103 is now SMT.
2024-12-16 Controller section is mostly SMT now.
2024-12-16 Relocate RN101.
2024-12-16 Relocate the crystal.
2024-12-17 Moved IODEC... I am probably going to just reroute the whole board.
2024-12-17 Make the 74LVC245s SMT components.
2024-12-17 Make the SRAM SMT. Man, this frees up a lot of real-estate.
2024-12-17 Add the SGM memory logic chips, clean out board routing on the left half of the board.
2024-12-17 Move the IODEC and MEMDEC chips around. They will be re-pinned to make this layout work better.
2024-12-17 Re-pin the inputs of the IODEC GAL, and make it take A0-A7 in prep for SGM additions.
2024-12-17 Rearrange the MEMDEC GAL to work better with the new board layout.
2024-12-17 Fix a keep-out.
2024-12-17 Add the XRAMEN and ROMEN signals to the MEMDEC GAL.
2024-12-17 Add all of the SGM IODEC signals and re-pin the outputs to work better with the new board layout.
2024-12-18 Put the AY-3-8910 on the schematic. Need to make some more room on the board.
2024-12-18 Move the video module to the right, making room for the AY-3-8910.
2024-12-18 Put the AY-3-8910 on the board, clarify part numbers for the 74xx chips to ensure the correct SOIC footprints.
2024-12-18 I think that's the whole right side of the board now routed.
2024-12-18 I think that's all the address lines now.
2024-12-18 Fix a dumb mistake in the power supply (put the reservoir cap on VCC, not VBUS), and fix a bunch of unconnected items.
2024-12-18 All the connections! (Except zones.)
2024-12-18 Fix some more DRC errors.
2024-12-19 Tidy up silk screen.
2024-12-19 Re-fill zones, re-enable text constraint warnings.
2024-12-19 Tidy up silk screen for D401.
2024-12-19 Re-enable silk screen overlap and clearance warnings. The resulting warnigns are expected and OK.
2024-12-20 Update some of the design details to reflect SGM capability.
2024-12-21 More README updates / fixes.
2024-12-21 Update dates / version numbers in drawings.
2024-12-21 Add the SGM extensions to the IODEC.
2024-12-21 Add SGM XRAMEN / ROMEN logic.
2024-12-21 Update Mouser part numbers / data sheet links.
2024-12-21 Replace schematic and board render images.
2024-12-21 Update silk screen for part numbers.
2024-12-21 Update the BoM.
2024-12-21 Gonna tag 2.0 pre-release soon!
2024-12-21 Note the op-amp audio output re-work for 0.2.
2024-12-21 Update schematic and PCB render for rev 0.2.
2024-12-21 Note rev 0.2 changes.
2024-12-21 Note 2.0 changes.
2024-12-22 Add / correct a bunch of Mouser part numbers for the BoM.
2024-12-22 Update the BoM with corrected part numbers for the caps, add part numbers for a bunch of the jellybean parts.
2024-12-22 Note rev 2.0.1, which contains corrections to the BoM.
2024-12-22 Readme updates for 2.0.1.
2024-12-22 WIP simulation of all of the address decoding logic, for illustrative purposes.
2024-12-23 Checkpoint address decoder simulation -- there are still a few bugs in the sim, it seems.
2024-12-23 Add the rest of the AY-3-8910 signal decoding.
2024-12-29 Dec 29 update.
2024-12-30 Oops, I effed up the MEMDEC GAL for disable-BIOS SGM games!
2024-12-30 Fix an issue with the memory address decoder for SGM games that disable the BIOS ROM: Use the /RD signal rather than the /WR dignal to distinguish reads vs writes to the first 8KB of the address spac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
2024-12-31 Update the simulation to reflect the changes to MEMDEC for rev 2.1.
2024-12-31 Oops, update the main part of the simulation as well.
2024-12-31 Add a simulation for the upcoming AY-3-8910 clock fix interposer board for rev 2.x CoPicoVisions.
2024-12-31 Add an AY-3-8910 interposer board for rev 2.x CoPicoVisions that fixes the AY-3-8910 clock input problem by dividing the clock by 2 with a D-type flip-flop.
2024-12-31 Add PCB render and schematic PDF for the AY interposer board.
2024-12-31 Add rework procedure for rev 2.x AY-3-8910 clock issue.
2024-12-31 Fix a typo in the markdown.
2024-12-31 Another 2.1 change -- AY-3-8910 clock problem rework procedure.
2024-12-31 Get ready to tag 2.1.
2025-01-01 Fix typo and add a seasonal greeting!
2025-01-01 Overhaul the clock circuit to use a 14MHz oscillator and counter chip to divide the clock by 4 (CPUCLK) and 8 (AYCLK).
    Welcome to rev 3.0.
2025-01-07 Switch to the upstream-issue-28 branch until Troy merges the changes.
2025-01-23 U102 is now an SOT-23 package.
2025-01-23 Change Q401 and Q402 to SOT-523 packages.
2025-01-24 Change the VGA resistor ladder DAC to surface mount packages.
2025-01-24 Update issue date.
2025-01-26 Now that there's room, re-center the "brand name" silk screen.
2025-02-17 Skeleton of a utility that can test the memory map.
2025-02-18 Test 1 - Ensure that base RAM mirrors every 1K in the default config.
2025-02-18 Add memset(), memcpy(), memcmp().
2025-02-18 Add test 2 -- verify that the BIOS ROM page is read-only. Data is copied to the underlying RAM for a subsequent test.
2025-02-18 Add a test 3 that ensures that extended RAM is not enabled by default.
2025-02-18 Don't stop if a test fails.
2025-02-19 Clean up test 1 a little.
2025-02-19 Further shorten some messages.
2025-02-19 Add test 4 -- verify extended RAM after enabled.
2025-02-19 Move test4 -> test5, and add a new test4 to check non-mirroring of base RAM regions.
2025-02-19 Don't set the row in each test -- do it in main().
2025-02-19 Print message about enabling extended RAM.
2025-02-19 Add a different test pattern for each 1K in test 5.
2025-02-20 Zero extended base and re-check extended RAM.
2025-02-20 Add ext base RAM test and disabled-ROM test.
2025-02-21 Add an XRAMAD signal that is high **unless** we're accessing the base RAM page with extended RAM disabled. This signal will be used to gate A10-A12 to get the base CV "mirroring" behavior (which curr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
2025-02-21 - If test8 fails, hex dump the test pattern area. - XXX Until the board is re-worked, enable extended RAM while we write the test pattern to the ROM area when the ROM is disabled. If we don't do this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
2025-02-21 Gate A10-A12 of the SRAM using the new XRAMAD signal coming from the MEMDEC GAL, rather than from XRAMEN.

Notices in the files:
README.md:
CC BY-SA 4.0
design-files/CoPicoVision.kicad_pcb:
(c) 2024 Jason R. Thorpe.  See LICENSE.
