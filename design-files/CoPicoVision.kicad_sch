File: design-files/CoPicoVision.kicad_sch (KiCad schematic)
At the start: 27 parts, among them J101 USB_C_Receptacle_PowerOnly_6P, Q101 MMFTP3334K-AQ, SW101 SW_Push, SW102 SW_Push, U101 Z80CPU, U102 DS1813, U103 74ACT05, U104 ICL7660A, U105 MAX16054, X101 3.579545MHZ

Commit message: Getting closer with PCB layout.
Connections:
- net GND: now also SW101.2, U102.3 (GND)
Changed lines of the file:
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@@
   (junction (at 89.408 138.303) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 90.551 180.975) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 31.369 188.468) (diameter 0) (color 0 0 0 0)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "power:GND") (at 90.551 180.975 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR0119" (at 90.551 187.325 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 90.551 185.42 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 90.551 180.975 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 90.551 180.975 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "CoPicoVision"
+        (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
+          (reference "#PWR0119") (unit 1)
+        )
+      )

Commit message: Add mounting holes around the cartridge area to reinforce it when carts are being inserted.
Parts:
- added H105, H106, H107, H108: MountingHole, MountingHole:MountingHole_3.5mm, symbol Mechanical:MountingHole
Other:
- moved on the sheet: H101, H102, H103, H104
Changed lines of the file:
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@@
+    )
+  )
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.811 66.675 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H105" (at 269.367 66.04 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.367 68.58 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.811 66.675 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.811 66.675 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (instances
+      (project "CoPicoVision"
+        (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
+          (reference "H105") (unit 1)
+        )
+      )
     )
   )
@@
     )
   )
-  (symbol (lib_id "Mechanical:MountingHole") (at 79.375 191.516 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "H102" (at 82.931 190.881 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "MountingHole" (at 82.931 193.421 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 79.375 191.516 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 79.375 191.516 0)
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.684 50.292 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H102" (at 269.24 49.657 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.24 52.197 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.684 50.292 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.684 50.292 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
           (reference "#PWR0117") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.938 77.597 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H107" (at 269.494 76.962 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.494 79.502 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.938 77.597 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.938 77.597 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (instances
+      (project "CoPicoVision"
+        (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
+          (reference "H107") (unit 1)
         )
       )
@@
     )
   )
-  (symbol (lib_id "Mechanical:MountingHole") (at 59.944 191.643 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "H101" (at 63.5 191.008 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "MountingHole" (at 63.5 193.548 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 59.944 191.643 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 59.944 191.643 0)
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.684 45.085 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H101" (at 269.24 44.45 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.24 46.99 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.684 45.085 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.684 45.085 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Mechanical:MountingHole") (at 99.695 191.516 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "H103" (at 103.251 190.881 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "MountingHole" (at 103.251 193.421 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 99.695 191.516 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 99.695 191.516 0)
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.811 56.007 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H103" (at 269.367 55.372 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.367 57.912 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.811 56.007 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.811 56.007 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
         (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
           (reference "C103") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.938 83.058 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H108" (at 269.494 82.423 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.494 84.963 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.938 83.058 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.938 83.058 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (instances
+      (project "CoPicoVision"
+        (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
+          (reference "H108") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.811 71.882 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H106" (at 269.367 71.247 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.367 73.787 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.811 71.882 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.811 71.882 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (instances
+      (project "CoPicoVision"
+        (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4"
+          (reference "H106") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 47.625 149.352 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
@@
     )
   )
-  (symbol (lib_id "Mechanical:MountingHole") (at 118.237 190.881 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "H104" (at 121.793 190.246 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Value" "MountingHole" (at 121.793 192.786 0)
-      (effects (font (size 1.27 1.27)) (justify left))
-    )
-    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 118.237 190.881 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 118.237 190.881 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "Mechanical:MountingHole") (at 265.811 61.468 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "H104" (at 269.367 60.833 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "MountingHole" (at 269.367 63.373 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "MountingHole:MountingHole_3.5mm" (at 265.811 61.468 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 265.811 61.468 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Add cartridge connector.
Parts:
- added C108: 0.1µF, Capacitor_SMD:C_0805_2012Metric_Pad1.18x1.45mm_HandSolder, symbol Device:C_Small
- added J102: Conn_02x15_Odd_Even, symbol Connector_Generic:Conn_02x15_Odd_Even
Connections:
- net A0: now also J102.7 (Pin_7)
- net A1: now also J102.9 (Pin_9)
- net A10: now also J102.16 (Pin_16)
- net A11: now also J102.14 (Pin_14)
- net A12: now also J102.24 (Pin_24)
- net A13: now also J102.19 (Pin_19)
- net A14: now also J102.20 (Pin_20)
- net A2: now also J102.11 (Pin_11)
- net A3: now also J102.15 (Pin_15)
- net A4: now also J102.17 (Pin_17)
- net A5: now also J102.21 (Pin_21)
- net A6: now also J102.23 (Pin_23)
- net A7: now also J102.25 (Pin_25)
- net A8: now also J102.28 (Pin_28)
- net A9: now also J102.26 (Pin_26)
- net D0: now also J102.5 (Pin_5)
- net D1: now also J102.3 (Pin_3)
- net D2: now also J102.1 (Pin_1)
- net D3: now also J102.4 (Pin_4)
- net D4: now also J102.6 (Pin_6)
- net D5: now also J102.8 (Pin_8)
- net D6: now also J102.10 (Pin_10)
- net D7: now also J102.12 (Pin_12)
- net GND: now also C108.2, J102.13 (Pin_13), J102.29 (Pin_29)
- net VCC: now also C108.1, J102.30 (Pin_30)
- new net ~{CRT8SEL}: J102.18 (Pin_18)
- new net ~{CRTASEL}: J102.22 (Pin_22)
- new net ~{CRTCSEL}: J102.2 (Pin_2)
- new net ~{CRTESEL}: J102.27 (Pin_27)

Commit message: Cartridge slot.
Parts:
- J102: footprint (none) -> jrt-Connectors:Sullins_Cart_Slot; Mouser (none) -> 571-5530843-2
Changed lines of the file:
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@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "" (at 197.612 117.856 0)
+    (property "Footprint" "jrt-Connectors:Sullins_Cart_Slot" (at 197.612 117.856 0)
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "~" (at 197.612 117.856 0)
+    (property "Datasheet" "https://www.te.com/commerce/DocumentDelivery/DDEController?Action=srchrtrv&DocNm=5530843&DocType=Customer+Drawing&DocLang=English&PartCntxt=5530843-2&DocFormat=pdf" (at 197.612 117.856 0)
       (effects (font (size 1.27 1.27)) hide)
     )
+    (property "Mouser" "571-5530843-2" (at 197.612 117.856 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
