File: design-files/CoPicoVision_controllers.kicad_sch (KiCad schematic)
At the start: 2 parts, among them J401 DE9_Plug_MountingHoles, J402 DE9_Plug_MountingHoles

Commit message: Checkpoint on controller circuit.
Parts:
- added C101, C103, C104: 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, symbol Device:C_Small
- added R401, R402: 210R, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
- added RN101: 3K3, Resistor_THT:R_Array_SIP9, symbol Device:R_Network08_Split
- added RN401, RN402: 22K, Resistor_THT:R_Array_SIP8, symbol Device:R_Network07
- added U103: 74ACT05, Package_DIP:DIP-14_W7.62mm_Socket, symbol 74xx:74LS05
- added U401, U402: 74LS541, Package_DIP:DIP-20_W7.62mm_Socket, symbol 74xx:74LS541
- added U403: 74HCT00, Package_DIP:DIP-14_W7.62mm_Socket, symbol 74xx:74HCT00
- J401: value DE9_Plug_MountingHoles -> Controller 1
- J402: value DE9_Plug_MountingHoles -> Controller 2
Connections:
- net GND: now reaches J401.0 (PAD)
- net GND: now also J402.0 (PAD), C101.2, C103.2, C104.2, R402.2, U401.10 (GND), U402.10 (GND), U403.7 (GND)
- net C1_1: now reaches J401.1
- net C1_1: now also RN401.2 (R1), U401.2 (A0)
- net C1_2: now reaches J401.2
- net C1_2: now also RN401.4 (R3), U401.4 (A2)
- net C1_3: now reaches J401.3
- net C1_3: now also RN401.5 (R4), U401.5 (A3)
- net C1_4: now reaches J401.4
- net C1_4: now also RN401.3 (R2), U401.3 (A1)
- net ~{PAD_EN}: now reaches J401.5
- net ~{PAD_EN}: now also J402.5
- net C1_6: now reaches J401.6
- net C1_6: now also RN401.8 (R7), U401.8 (A6)
- net C1_7: now reaches J401.7
- net C1_7: now also RN401.7 (R6), U401.7 (A5)
- net ~{NESW_EN}: now reaches J401.8
- net ~{NESW_EN}: now also J402.8
- net C1_9: now reaches J401.9
- net C2_1: now reaches J402.1
- net C2_1: now also RN402.2 (R1), U402.2 (A0)
- net C2_2: now reaches J402.2
- net C2_2: now also RN402.4 (R3), U402.4 (A2)
- net C2_3: now reaches J402.3
- net C2_3: now also RN402.5 (R4), U402.5 (A3)
- net C2_4: now reaches J402.4
- net C2_4: now also RN402.3 (R2), U402.3 (A1)
- net C2_6: now reaches J402.6
- net C2_6: now also RN402.8 (R7), U402.8 (A6)
- net C2_7: now reaches J402.7
- net C2_7: now also RN402.7 (R6), U402.7 (A5)
- net C2_9: now reaches J402.9
- new net: RN402.6 (R5), U402.6 (A4)
- new net: RN401.6 (R5), U401.6 (A4)
- new net: RN101.6 (R5.2), U103.6, U401.19 (G2)
- new net 2V5: R401.2, R402.1, RN401.1 (common), RN402.1 (common)
- new net A1: U103.5, U402.19 (G2)
- new net D0: U401.18 (Y0), U402.18 (Y0)
- new net D1: U401.17 (Y1), U402.17 (Y1)
- new net D2: U401.16 (Y2), U402.16 (Y2)
- new net D3: U401.15 (Y3), U402.15 (Y3)
- new net D4: U401.14 (Y4), U402.14 (Y4)
- new net D5: U401.13 (Y5), U402.13 (Y5)
- new net D6: U401.12 (Y6), U402.12 (Y6)
- new net D7: U401.11 (Y7), U402.11 (Y7)
- new net VCC: C101.1, C103.1, C104.1, R401.1, RN101.1 (R1), U401.20 (VCC), U402.20 (VCC), U403.14 (VCC)
- new net ~{CRSEL}: U401.1 (G1), U402.1 (G1)
Other:
- moved on the sheet: J401, J402

Commit message: Controller circuit checkpoint.
Parts:
- added C101 (x2): 0.01µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, symbol Device:C_Small
- added R403, R404: 1.5K, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
- added R405, R406: 120R, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
Connections:
- net GND: now also C101.1, C101.2
- net ~{NESW_EN}: now also C101.2, R406.1
- net ~{PAD_EN}: now also C101.1, R405.1
- net at U403.1: now also U403.6, R404.1, R406.2
- net ~{C1WSEL}: now reaches U403.2
- net at U403.3: now also U403.5, R403.1, R405.2
- net ~{C2WSEL}: now reaches U403.4
- new net -5V: R403.2, R404.2
Other:
- note added: "~{C1WSEL} low -> ~{NESW_EN} low ~{C2WSEL} low -> ~{PAD_EN} low"
- moved on the sheet: J401, J402, U403A, U403B

Commit message: Controller checkpoint.
Parts:
- added C104 (x2): .047µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, symbol Device:C_Small
- added C104 (x2): 100pF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, symbol Device:C_Small
- added C104 (x2): 0.1µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, symbol Device:C_Small
- added Q401, Q402: 2N3904, Package_TO_SOT_THT:TO-92_Inline, symbol Transistor_BJT:2N3904
- added R407, R410: 1.8K, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
- added R408, R411: 22K, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
- added R409, R412: 10K, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
Connections:
- net C1_9: now also R407.1
- net C2_9: now also R410.1
- net GND: now also C104.2, C104.2, Q401.1 (E), Q402.1 (E)
- net VCC: now also R409.2, R412.2
- net C2_D4: now reaches RN402.6 (R5), U402.6 (A4)
- net C2_D4: now also U403.12, C104.1
- net at U403.10: now also C104.1, R407.2
- net C1_D7: now reaches U403.8
- net C1_D7: now also U401.9 (A7), C104.1, R408.1
- net C1_D4: now reaches U403.9
- net C1_D4: now also RN401.6 (R5), U401.6 (A4), C104.1
- net C2_D7: now reaches U402.9 (A7)
- net C2_D7: now also U403.11, C104.1, R411.1
- net at U403.13: now also C104.1, R410.2
- new net: C104.2, Q402.3 (C), R412.1
- new net: C104.2, Q401.2 (B), R408.2
- new net: C104.2, Q401.3 (C), R409.1
- new net: C104.2, Q402.2 (B), R411.2
Other:
- moved on the sheet: U403C, U403D

Commit message: Final controller checkpoint.  Managed to sqeeeze it all onto the board.
Parts:
- added C101 (x2): 0.01µF, Capacitor_THT:C_Disc_D3.8mm_W2.6mm_P2.50mm, symbol Device:C_Small
- added D401, D402: 1N4001, Diode_THT:D_DO-41_SOD81_P10.16mm_Horizontal, symbol Diode:1N4001
- added R413: 1.5K, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
- added R414, R415: 100K, Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal, symbol Device:R_Small
- added unit 4 of U103
Connections:
- net C1_D7: now also C101.1
- net C2_D7: now also C101.2
- net GND: now also R413.1
- net VCC: now also R414.2, R415.2
- new net: C101.1, D402.2 (A), R415.1
- new net: D401.1 (K), D402.1 (K), R413.2, U103.9
- new net: C101.2, D401.2 (A), R414.1
- new net ~{INT}: U103.8

Commit message: Most of the controller interface routed.
Connections:
- net C1_D4: now also U403.12; no longer U403.9
- net C1_D7: now also U403.11; no longer U403.8
- net C2_D4: now also U403.9; no longer U403.12
- net C2_D7: now also U403.8; no longer U403.11
- net at C104.1, R410.2: now also U403.10; no longer U403.13
- net at C104.1, R407.2: now also U403.13; no longer U403.10
Other:
- moved on the sheet: U403C, U403D
Changed lines of the file:
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@@
   (junction (at 51.816 107.823) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 34.671 97.663) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 104.775 46.863) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 231.521 137.922) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 17.78 186.309) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 239.903 74.803) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 68.199 156.845) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 221.361 127.762) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 231.521 62.103) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 144.78 178.435) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 228.981 135.382) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 151.765 95.25) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 102.87 144.272) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 28.829 191.389) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 92.075 56.896) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 63.881 113.284) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 63.881 92.329) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 223.901 54.483) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 228.981 59.563) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 51.816 97.663) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 34.671 102.743) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 226.441 57.023) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 97.155 56.896) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 234.061 140.462) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 34.671 107.823) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 51.816 102.743) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 70.104 59.436) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 177.8 87.63) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 160.274 95.25) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 160.274 102.87) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 28.829 186.309) (diameter 0) (color 0 0 0 0)
+  )
+  (junction (at 221.361 51.943) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 90.17 154.305) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 34.671 97.663) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 104.775 46.863) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 231.521 137.922) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 17.78 186.309) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 239.903 74.803) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 68.199 156.845) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 221.361 127.762) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 231.521 62.103) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 144.78 178.435) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 228.981 135.382) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 151.765 95.25) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 102.87 144.272) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 92.075 56.896) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 28.829 191.389) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 63.881 113.284) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 63.881 92.329) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 223.901 54.483) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 228.981 59.563) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 51.816 97.663) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 34.671 102.743) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 226.441 57.023) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 97.155 56.896) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 234.061 140.462) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 34.671 107.823) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 51.816 102.743) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 70.104 59.436) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 177.8 87.63) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 160.274 95.25) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 160.274 102.87) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 28.829 186.309) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 221.361 51.943) (diameter 0) (color 0 0 0 0)
   )
   (wire (pts (xy 95.25 144.272) (xy 102.87 144.272))
@@
     )
   )
-  (symbol (lib_id "74xx:74HCT00") (at 84.455 56.896 0) (unit 3)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "U403" (at 84.4467 48.768 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "74HCT00" (at 84.4467 51.308 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Package_DIP:DIP-14_W7.62mm_Socket" (at 84.455 56.896 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "http://www.ti.com/lit/gpn/sn74hct00" (at 84.455 56.896 0)
+  (symbol (lib_id "74xx:74HCT00") (at 82.55 154.305 0) (unit 3)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U403" (at 82.5417 146.177 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "74HCT00" (at 82.5417 148.717 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Package_DIP:DIP-14_W7.62mm_Socket" (at 82.55 154.305 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "http://www.ti.com/lit/gpn/sn74hct00" (at 82.55 154.305 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "74xx:74HCT00") (at 82.55 154.305 0) (unit 4)
-    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
-    (property "Reference" "U403" (at 82.5417 146.05 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "74HCT00" (at 82.5417 148.59 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Package_DIP:DIP-14_W7.62mm_Socket" (at 82.55 154.305 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "http://www.ti.com/lit/gpn/sn74hct00" (at 82.55 154.305 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+  (symbol (lib_id "74xx:74HCT00") (at 84.455 56.896 0) (unit 4)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "U403" (at 84.4467 48.641 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Value" "74HCT00" (at 84.4467 51.181 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "Package_DIP:DIP-14_W7.62mm_Socket" (at 84.455 56.896 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "http://www.ti.com/lit/gpn/sn74hct00" (at 84.455 56.896 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: Use a 4-resistor pack, not 8.
Parts:
- RN101: footprint Resistor_THT:R_Array_SIP9 -> Resistor_THT:R_Array_SIP5; symbol Device:R_Network08_Split -> Device:R_Network04_Split
Connections:
- net at U103.6, U401.19 (G2): no longer RN101.6 (R5.2)
Changed lines of the file:
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@@
     )
   )
-  (symbol (lib_id "Device:R_Network08_Split") (at 239.903 78.613 180) (unit 5)
+  (symbol (lib_id "Device:R_Network04_Split") (at 239.903 78.613 180) (unit 5)
     (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
     (property "Reference" "RN101" (at 237.744 79.248 0)
@@
       (effects (font (size 1.27 1.27)) (justify left))
     )
-    (property "Footprint" "Resistor_THT:R_Array_SIP9" (at 241.935 78.613 90)
+    (property "Footprint" "Resistor_THT:R_Array_SIP5" (at 241.935 78.613 90)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     (pin "4")
     (pin "5")
-    (pin "6")
-    (pin "7")
-    (pin "8")
-    (pin "9")
     (instances
       (project "CoPicoVision"
@@
         )
         (path "/d4d4c0fa-7a39-4b72-9fdb-c481b1e41ed4/e0ac0253-c368-4a00-80da-4eff7e9af602"
-          (reference "RN101") (unit 5)
+          (reference "RN101") (unit 4)
         )
       )

Commit message: Add a power LED.
Changed lines of the file:
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@@
   (junction (at 17.78 186.309) (diameter 0) (color 0 0 0 0)
-  )
-  (junction (at 239.903 74.803) (diameter 0) (color 0 0 0 0)
   )
   (junction (at 68.199 156.845) (diameter 0) (color 0 0 0 0)
